options:
  parameters:
    author: SP5WWP
    generate_options: no_gui
    id: bench
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 12.5e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 12.5e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qam_constellation
  id: variable_constellation
  parameters:
    const_points: '[-1. -1.j, -1. -0.71428571j, -1. -0.14285714j, -1. -0.42857143j, -1. +1.j, -1. +0.71428571j, -1. +0.14285714j, -1. +0.42857143j, -0.71428571-1.j, -0.71428571-0.71428571j, -0.71428571-0.14285714j, -0.71428571-0.42857143j, -0.71428571+1.j, -0.71428571+0.71428571j, -0.71428571+0.14285714j, -0.71428571+0.42857143j, -0.14285714-1.j, -0.14285714-0.71428571j, -0.14285714-0.14285714j, -0.14285714-0.42857143j, -0.14285714+1.j, -0.14285714+0.71428571j, -0.14285714+0.14285714j, -0.14285714+0.42857143j, -0.42857143-1.j, -0.42857143-0.71428571j, -0.42857143-0.14285714j, -0.42857143-0.42857143j, -0.42857143+1.j, -0.42857143+0.71428571j, -0.42857143+0.14285714j, -0.42857143+0.42857143j, 1. -1.j, 1. -0.71428571j, 1. -0.14285714j, 1. -0.42857143j, 1. +1.j, 1. +0.71428571j, 1. +0.14285714j, 1. +0.42857143j, 0.71428571-1.j, 0.71428571-0.71428571j, 0.71428571-0.14285714j, 0.71428571-0.42857143j, 0.71428571+1.j, 0.71428571+0.71428571j, 0.71428571+0.14285714j, 0.71428571+0.42857143j, 0.14285714-1.j, 0.14285714-0.71428571j, 0.14285714-0.14285714j, 0.14285714-0.42857143j, 0.14285714+1.j, 0.14285714+0.71428571j, 0.14285714+0.14285714j, 0.14285714+0.42857143j, 0.42857143-1.j, 0.42857143-0.71428571j, 0.42857143-0.14285714j, 0.42857143-0.42857143j, 0.42857143+1.j, 0.42857143+0.71428571j, 0.42857143+0.14285714j, 0.42857143+0.42857143j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: np.arange(64)
    type: calcdist
  states: {state: disabled}
- name: qam_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: zmq_size
  id: variable
  parameters:
    value: 2**11
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: 0.5 + 0.5j
    type: complex
  states: {state: disabled}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*np.pi*800.0)/48e3
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 48e3/(2.0*np.pi*800.0)
  states: {state: disabled}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '4'
    minimum: '0'
    seed: '73'
    type: byte
  states: {state: disabled}
- name: analog_random_uniform_source_x_0_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: 255+1
    minimum: '0'
    seed: '73'
    type: byte
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:0,1
    num_inputs: '2'
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: hw:0,1
    num_inputs: '2'
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"hw:0,0"'
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1.5'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Remove overshoot
    const: 1/2
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_size
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_size
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qam_constellation
    differential: 'False'
    excess_bw: '0.2'
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2.0*math.pi*0.000015
    max_dev: '0.005'
    osps: '10'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[0.004562185464, -0.003315159603, 0.004494660764, -0.005933215824, 0.007662642297, -0.009730151262, 0.012163462902, -0.015021624093, 0.018344736003, -0.022179571087, 0.026587935938, -0.031624350959, 0.037349001966, -0.043825719260, 0.051125585868, -0.059326237377, 0.068504390315, -0.078746186598, 0.090147725138, -0.102813489566, 0.116858526852, -0.132408962019, 0.149609118181, -0.168623734209, 0.189641904748, -0.212886091306, 0.238618491973, -0.267152027409, 0.298864858677, -0.334221364400, 0.373800820471, -0.418331953197, 0.468744199982, -0.526240588097, 0.592399581386, -0.669319857641, 0.759823522591, -0.867734659884, 0.998215908414, -1.158013367129, 1.354923496534, -1.593658456679, 1.856602265650, -2.021519762741, 1.526746272983, 1.526746272983, -2.021519762741, 1.856602265650, -1.593658456679, 1.354923496534, -1.158013367129, 0.998215908414, -0.867734659884, 0.759823522591, -0.669319857641, 0.592399581386, -0.526240588097, 0.468744199982, -0.418331953197, 0.373800820471, -0.334221364400, 0.298864858677, -0.267152027409, 0.238618491973, -0.212886091306, 0.189641904748, -0.168623734209, 0.149609118181, -0.132408962019, 0.116858526852, -0.102813489566, 0.090147725138, -0.078746186598, 0.068504390315, -0.059326237377, 0.051125585868, -0.043825719260, 0.037349001966, -0.031624350959, 0.026587935938, -0.022179571087, 0.018344736003, -0.015021624093, 0.012163462902, -0.009730151262, 0.007662642297, -0.005933215824, 0.004494660764, -0.003315159603, 0.004562185464]'
    type: ccf
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[-0.004922351175, 0.003062312786, -0.003988005723, 0.005093026471, -0.006387910595, 0.007891072265, -0.009631151264, 0.011632714520, -0.013916801818, 0.016510602853, -0.019447899813, 0.022762725822, -0.026489053160, 0.030666304328, -0.035341805576, 0.040569413853, -0.046410234359, 0.052936430186, -0.060234822845, 0.068410565967, -0.077593809312, 0.087949364525, -0.099688344119, 0.113084649942, -0.128501675734, 0.146433855322, -0.167570246996, 0.192896588415, -0.223867016653, 0.262703169287, -0.312935247724, 0.380411431327, -0.475149638186, 0.613934011379, -0.814825613620, 0.966352417857, 0.966352417857, -0.814825613620, 0.613934011379, -0.475149638186, 0.380411431327, -0.312935247724, 0.262703169287, -0.223867016653, 0.192896588415, -0.167570246996, 0.146433855322, -0.128501675734, 0.113084649942, -0.099688344119, 0.087949364525, -0.077593809312, 0.068410565967, -0.060234822845, 0.052936430186, -0.046410234359, 0.040569413853, -0.035341805576, 0.030666304328, -0.026489053160, 0.022762725822, -0.019447899813, 0.016510602853, -0.013916801818, 0.011632714520, -0.009631151264, 0.007891072265, -0.006387910595, 0.005093026471, -0.003988005723, 0.003062312786, -0.004922351175]'
    type: ccf
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 25e3
    decim: '1'
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from commpy.modulation import QAMModem
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6.25e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 6.25e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '42001'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '125'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '3'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '48'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '36'
    type: ccc
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '10'
    interp: '10'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {state: disabled}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: fir_filter_fff
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17001
    timeout: '150'
    type: complex
    vlen: zmq_size
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17001
    timeout: '150'
    type: float
    vlen: zmq_size
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_complex_to_float_0, '0']
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_1, '0']
- [analog_random_uniform_source_x_0, '0', blocks_uchar_to_float_0, '0']
- [analog_random_uniform_source_x_0_0, '0', digital_constellation_modulator_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_complex_to_float_0_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_float_0_0, '1', audio_sink_0_0, '1']
- [blocks_correctiq_0, '0', blocks_stream_to_vector_2, '0']
- [blocks_correctiq_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_float_to_complex_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_multiply_const_vxx_1, '0', rational_resampler_xxx_0_0, '0']
- [blocks_stream_to_vector_1, '0', zeromq_pub_sink_0_0, '0']
- [blocks_stream_to_vector_2, '0', zeromq_pub_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_symbol_sync_xx_0_0, '0', blocks_stream_to_vector_1, '0']
- [fir_filter_xxx_0, '0', blocks_correctiq_0, '0']
- [fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_complex_to_float_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_2, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0_0, '0', fir_filter_xxx_0_0, '0']
- [rational_resampler_xxx_1, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_2, '0', network_udp_sink_0, '0']
- [root_raised_cosine_filter_0, '0', analog_frequency_modulator_fc_0, '0']
- [root_raised_cosine_filter_1, '0', digital_symbol_sync_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
