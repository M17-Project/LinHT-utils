options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Foundation 2025
    generate_options: no_gui
    id: som_fm_ctcss
    output_language: python
    title: LinHT FM transceiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: analog_ctcss_squelch_ff_0
  id: analog_ctcss_squelch_ff
  parameters:
    freq: ctcss
    gate: 'False'
    len: '0'
    level: '0.025'
    ramp: '0'
    rate: int(32e3)
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '32000'
    tau: emph*1e-6
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: '8000'
    tau: emph*1e-6
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*np.pi*(bw+1)*2.5e3)/32000.0
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 32e3/(2.0*np.pi*(bw+1)*2.5e3)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.05'
    comment: CTCSS tone source
    freq: ctcss
    offset: '0'
    phase: '0'
    samp_rate: '8000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    comment: Baseband output
    device_name: hw:sx1255
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    comment: Audio output
    device_name: hw:wm8960audio
    samp_rate: '8000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: Microphone input
    device_name: hw:wm8960audio
    samp_rate: '8000'
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    comment: Baseband input
    device_name: hw:sx1255
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '300'
    samp_rate: '8000'
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '4'
    gain: '4'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '300'
    samp_rate: '32000'
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: iqdc
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: bw
  id: parameter
  parameters:
    comment: |-
      Bandwidth:
      0 - 12.5 kHz
      1 - 25 kHz
    label: FM bandwidth
    short_id: b
    type: intx
    value: '0'
  states: {}
- name: ctcss
  id: parameter
  parameters:
    label: CTCSS tone frequency
    short_id: t
    type: eng_float
    value: '127.3'
  states: {}
- name: emph
  id: parameter
  parameters:
    label: De/preemphasis time constant in microseconds
    short_id: e
    type: eng_float
    value: '75'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: iqdc
  id: parameter
  parameters:
    label: IQ DC offset
    short_id: d
    type: complex
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Channelizer
    cutoff_freq: 12.5e3*(bw+1)/2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 12.5e3*(bw+1)/2.0
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: 4*8
    interp: '500'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '32'
    type: ccc
  states: {}

connections:
- [analog_ctcss_squelch_ff_0, '0', analog_fm_deemph_0, '0']
- [analog_fm_deemph_0, '0', band_pass_filter_0_0, '0']
- [analog_fm_preemph_0, '0', band_pass_filter_0, '0']
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_ctcss_squelch_ff_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [audio_source_0, '0', analog_fm_preemph_0, '0']
- [audio_source_0_0, '0', blocks_float_to_complex_1, '0']
- [audio_source_0_0, '1', blocks_float_to_complex_1, '1']
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [band_pass_filter_0_0, '0', audio_sink_0_0_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0_0, '1']
- [blocks_float_to_complex_1, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_add_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_frequency_modulator_fc_0, '0']
- [rational_resampler_xxx_1, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
