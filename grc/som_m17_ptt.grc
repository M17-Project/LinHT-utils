options:
  parameters:
    author: Wojciech SP5WWP / Andreas OE3ANC
    copyright: M17 Foundation 2025
    generate_options: no_gui
    id: som_m17_ptt
    output_language: python
    run_options: run
    title: Sample M17 receiver with PTT via ZMQ
  states: {}

blocks:
- name: ch_flt
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 6.25e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 6.25e3
    win: window.WIN_HAMMING
  states: {}
- name: ptt
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: zmq_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*np.pi*800.0)/48e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 48e3/(2.0*math.pi*800.0)
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: hw:1,1
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    device_name: plughw:wm8960audio
    ok_to_block: 'False'
    samp_rate: '8000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"hw:SX1255"'
    num_outputs: '2'
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_source_1
  id: audio_source
  parameters:
    device_name: plughw:wm8960audio
    ok_to_block: 'False'
    samp_rate: '8000'
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: ptt
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (0.5 + 0j)
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '2'
    output_index: int(ptt)
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**14
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_len
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_len
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_len
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2*math.pi*0.00015
    max_dev: '0.005'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[0.004562185464, -0.003315159603, 0.004494660764, -0.005933215824, 0.007662642297, -0.009730151262, 0.012163462902, -0.015021624093, 0.018344736003, -0.022179571087, 0.026587935938, -0.031624350959, 0.037349001966, -0.043825719260, 0.051125585868, -0.059326237377, 0.068504390315, -0.078746186598, 0.090147725138, -0.102813489566, 0.116858526852, -0.132408962019, 0.149609118181, -0.168623734209, 0.189641904748, -0.212886091306, 0.238618491973, -0.267152027409, 0.298864858677, -0.334221364400, 0.373800820471, -0.418331953197, 0.468744199982, -0.526240588097, 0.592399581386, -0.669319857641, 0.759823522591, -0.867734659884, 0.998215908414, -1.158013367129, 1.354923496534, -1.593658456679, 1.856602265650, -2.021519762741, 1.526746272983, 1.526746272983, -2.021519762741, 1.856602265650, -1.593658456679, 1.354923496534, -1.158013367129, 0.998215908414, -0.867734659884, 0.759823522591, -0.669319857641, 0.592399581386, -0.526240588097, 0.468744199982, -0.418331953197, 0.373800820471, -0.334221364400, 0.298864858677, -0.267152027409, 0.238618491973, -0.212886091306, 0.189641904748, -0.168623734209, 0.149609118181, -0.132408962019, 0.116858526852, -0.102813489566, 0.090147725138, -0.078746186598, 0.068504390315, -0.059326237377, 0.051125585868, -0.043825719260, 0.037349001966, -0.031624350959, 0.026587935938, -0.022179571087, 0.018344736003, -0.015021624093, 0.012163462902, -0.009730151262, 0.007662642297, -0.005933215824, 0.004494660764, -0.003315159603, 0.004562185464]'
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 100e3
    decim: '1'
    samp_rate: samp_rate
    taps: ch_flt
    type: ccc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6.25e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 6.25e3
    win: window.WIN_HAMMING
  states: {}
- name: m17_m17_coder_0_0
  id: m17_m17_coder
  parameters:
    aes_subtype: '0'
    can: '0'
    debug: 'False'
    dst_id: SP5WWP
    encr_subtype: '0'
    encr_type: '0'
    key: ''
    meta: '"\x00\x00\x00\x00\x00\x00\x00\x00\x00\x00\x00\x00\x00\x00"'
    mode: '1'
    priv_key: ''
    seed: ''
    signed_str: 'False'
    src_id: OE3ANC
    type: '1'
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    callsign: 'True'
    debug_ctrl: 'True'
    debug_data: 'True'
    encr_type: '0'
    key: ''
    seed: ''
    signed_str: 'False'
    threshold: '2.0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '48'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '500'
    type: ccf
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_1_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '10'
    interp: '10'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    mode: codec2.MODE_3200
  states: {}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    mode: codec2.MODE_3200
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17005
    timeout: '100'
    type: float
    vlen: zmq_len
  states: {state: disabled}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17005
    timeout: '100'
    type: float
    vlen: zmq_len
  states: {state: disabled}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17005
    timeout: '100'
    type: complex
    vlen: zmq_len
  states: {state: disabled}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://10.17.17.1:17001
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://10.17.17.1:17002
    timeout: '100'
  states: {}

connections:
- [analog_frequency_modulator_fc_0_0, '0', blocks_selector_0, '1']
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [audio_source_1, '0', blocks_float_to_short_0, '0']
- [blocks_complex_to_float_0_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_float_0_0, '1', audio_sink_0_0, '1']
- [blocks_correctiq_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_correctiq_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_correctiq_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', blocks_selector_0, '0']
- [blocks_float_to_short_0, '0', vocoder_codec2_encode_sp_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_stream_to_vector_2, '0']
- [blocks_selector_0, '0', fir_filter_xxx_0, '0']
- [blocks_selector_0, '1', rational_resampler_xxx_1_0, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_2, '0']
- [blocks_stream_to_vector_0, '0', zeromq_pub_sink_0, '0']
- [blocks_stream_to_vector_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_stream_to_vector_1, '0', zeromq_pub_sink_1, '0']
- [blocks_stream_to_vector_2, '0', vocoder_codec2_decode_ps_0, '0']
- [blocks_vector_to_stream_0, '0', m17_m17_coder_0_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_stream_to_vector_0_0, '0']
- [digital_symbol_sync_xx_0, '0', m17_m17_decoder_0, '0']
- [fir_filter_xxx_0, '0', blocks_correctiq_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [m17_m17_coder_0_0, '0', root_raised_cosine_filter_1_0, '0']
- [m17_m17_decoder_0, '0', blocks_null_sink_0, '0']
- [m17_m17_decoder_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_2, '0', audio_sink_1, '0']
- [root_raised_cosine_filter_0, '0', blocks_stream_to_vector_0, '0']
- [root_raised_cosine_filter_0, '0', virtual_sink_0, '0']
- [root_raised_cosine_filter_1_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']
- [vocoder_codec2_encode_sp_0, '0', blocks_vector_to_stream_0, '0']
- [zeromq_sub_msg_source_0, out, blocks_msgpair_to_var_0, inpair]
- [zeromq_sub_msg_source_0_0, out, m17_m17_coder_0_0, end_of_transmission]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
