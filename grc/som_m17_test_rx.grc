options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Foundation 2025
    generate_options: no_gui
    id: som_m17_test_rx
    output_language: python
    run_options: run
    title: M17 test receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: zmq_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.01'
    gate: 'False'
    ramp: int(0.01*samp_rate)
    threshold: '-40'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 48e3/(2.0*math.pi*800.0)
  states: {}
- name: aud_sink
  id: parameter
  parameters:
    label: Audio device
    short_id: a
    type: str
    value: hw:0,0
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: aud_sink
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: bsb_src
    num_outputs: '2'
    samp_rate: '500000'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_len
    type: float
  states: {}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: bsb_src
  id: parameter
  parameters:
    label: Baseband source device
    short_id: b
    type: str
    value: hw:1,0
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: int(0.04*samp_rate)
    long_form: 'False'
    type: ff
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2*math.pi*0.00015
    max_dev: '0.005'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[0.004562185464, -0.003315159603, 0.004494660764, -0.005933215824, 0.007662642297, -0.009730151262, 0.012163462902, -0.015021624093, 0.018344736003, -0.022179571087, 0.026587935938, -0.031624350959, 0.037349001966, -0.043825719260, 0.051125585868, -0.059326237377, 0.068504390315, -0.078746186598, 0.090147725138, -0.102813489566, 0.116858526852, -0.132408962019, 0.149609118181, -0.168623734209, 0.189641904748, -0.212886091306, 0.238618491973, -0.267152027409, 0.298864858677, -0.334221364400, 0.373800820471, -0.418331953197, 0.468744199982, -0.526240588097, 0.592399581386, -0.669319857641, 0.759823522591, -0.867734659884, 0.998215908414, -1.158013367129, 1.354923496534, -1.593658456679, 1.856602265650, -2.021519762741, 1.526746272983, 1.526746272983, -2.021519762741, 1.856602265650, -1.593658456679, 1.354923496534, -1.158013367129, 0.998215908414, -0.867734659884, 0.759823522591, -0.669319857641, 0.592399581386, -0.526240588097, 0.468744199982, -0.418331953197, 0.373800820471, -0.334221364400, 0.298864858677, -0.267152027409, 0.238618491973, -0.212886091306, 0.189641904748, -0.168623734209, 0.149609118181, -0.132408962019, 0.116858526852, -0.102813489566, 0.090147725138, -0.078746186598, 0.068504390315, -0.059326237377, 0.051125585868, -0.043825719260, 0.037349001966, -0.031624350959, 0.026587935938, -0.022179571087, 0.018344736003, -0.015021624093, 0.012163462902, -0.009730151262, 0.007662642297, -0.005933215824, 0.004494660764, -0.003315159603, 0.004562185464]'
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6.25e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 6.25e3
    win: window.WIN_HAMMING
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    callsign: 'True'
    debug_ctrl: 'False'
    debug_data: 'True'
    encr_type: '0'
    key: ''
    seed: ''
    signed_str: 'False'
    threshold: '2.0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '48'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(48/8)
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: fir_filter_fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    mode: codec2.MODE_3200
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17005
    timeout: '100'
    type: complex
    vlen: zmq_len
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17006
    timeout: '100'
    type: float
    vlen: zmq_len
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', audio_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_correctiq_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_correctiq_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', fir_filter_xxx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_stream_to_vector_2, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_1, '0']
- [blocks_stream_to_vector_0, '0', zeromq_pub_sink_0, '0']
- [blocks_stream_to_vector_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_stream_to_vector_2, '0', vocoder_codec2_decode_ps_0, '0']
- [dc_blocker_xx_0, '0', virtual_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', m17_m17_decoder_0, '0']
- [fir_filter_xxx_0, '0', blocks_correctiq_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [m17_m17_decoder_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_1, '0', analog_pwr_squelch_xx_0, '0']
- [root_raised_cosine_filter_0, '0', dc_blocker_xx_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
